# IAR project speedometer.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: chip=2541; INT_HEAP_LEN=3072; HALNODEBUG; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; OSAL_CBTIMER_NUM_TASKS=1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\ble\controller\CC254x\include; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\ble\controller\CC254x\phy; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\ble\ROM; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Components\hal\target\CC2541ST; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\common\npi\npi_np; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\Profiles\Roles\CC254x; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\Profiles\Roles; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\Profiles\DevInfo; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\Profiles\Keys\CC254x; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\Profiles\Keys; C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\Profiles\OAD
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\common\cc2540\cc254x_f256_ebl.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group APP
    ./: main.c
    src/: OSAL_speedometer.c
  group HAL/Common
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/hal/common/: hal_drivers.c
  group HAL/Include
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/hal/target/CC2541ST/: hal_types.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/services/saddr/: saddr.h
  group HAL/Target/CC2541ST/Config
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/hal/target/CC2541ST/: hal_board_cfg.h
  group HAL/Target/CC2541ST/Drivers
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/hal/target/CC2541ST/: hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_keys.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c
  group HAL/Target/CC2541ST/Includes
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/hal/target/CC2541ST/: hal_aes.h hal_mcu.h
  group INCLUDE
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/ble/host/: linkdb.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/ble/controller/CC254x/include/: ll.h phy.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/common/npi/npi_np/: npi.h
  group LIB
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/common/npi/npi_np/: npi.c
  group OSAL
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/ble/include/: bcomdef.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheralBroadcaster.c peripheralBroadcaster.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/Include/: gapgattserver.h gattservapp.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Components/ble/host/: gatt_uuid.c
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/Profiles/OAD/: oad.h oad_target.c oad_target.h
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/Profiles/Roles/CC254x/: peripheral.c peripheral.h
  group TOOLS
    C:/Texas Instruments/BLE-CC254x-1.4.2.2/Projects/ble/config/: buildComponents.cfg buildConfig.cfg
